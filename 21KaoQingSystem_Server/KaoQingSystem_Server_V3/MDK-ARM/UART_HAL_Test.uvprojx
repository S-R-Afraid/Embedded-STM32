# Keil uVision project UART_HAL_Test.uvprojx, settings and files
target UART_HAL_Test (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Led_Key_HAL_register +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Hardware/Key;../Hardware/Led;../Hardware/LCD;../Hardware/ESP32;../Hardware/WIFI;../Hardware/RC522
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: MyRTC.c main.c gpio.c rtc.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c systemfunction.c
    ../Hardware/I2C/: MyI2C .c
    ../Hardware/Delay/: delay.c delay.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Hardware/Led
    ../Hardware/Led/: led.c
  group Hardware/Key
    ../Hardware/Key/: key.c
  group Hardware/LCD
    ../Hardware/LCD/: bsp_LCD_ILI9341.c MyUI.c MyUI.h
  group Hardware/ESP32
    ../Hardware/ESP32/: esp32.c
  group Hardware/Wifi
    ../Hardware/WIFI/: wifi.c
  group Hardware/RC522
    ../Hardware/RC522/: rc522.c
  group AHT20
    ../Hardware/AHT20/: atk_aht20.h atk_aht20.c
software components: CMSIS:CORE 4.3.0
