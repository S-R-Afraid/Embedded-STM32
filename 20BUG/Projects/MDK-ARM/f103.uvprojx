# Keil uVision project f103.uvprojx, settings and files
target Template (6220000::V6.22::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Users
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../Users/: stm32f1xx_it.c main.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_rtc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c
  group Readme
    ../../: readme.txt
  group Drivers/BSP
    ../../Drivers/BSP/BEEP/: beep.c
    ../../Drivers/BSP/EXTI/: exti.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/TIMER/: btim.c gtim.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/I2C/: MyI2C .c
    ../../Drivers/BSP/OLED/: OLED.c OLED_Data.c OLEDUI.c
    ../../Drivers/BSP/HC-SR04/: HC-SR04.c
    ../../Drivers/BSP/SPI/: MySPI.c
    ../../Drivers/BSP/ESP8266/: esp8266.c
    ../../Drivers/BSP/DRAWBUG/: DRAWBUG.c
